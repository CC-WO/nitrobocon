# Repository CC-WO/nitrobocon

File README.md:

# nitrobocon

## DEMO

## Features

## Requirement

MacOS 15 Mojave

## Installtion

[EAGLE](https://www.autodesk.co.jp/products/eagle/overview)

## Usage

## Note

## Author

- Author: CCWO
- E-mail: cc.ccwo.cc@gmail.com

## License

This repository is under [MIT license](https://en.wikipedia.org/wiki/MIT_License).

I want to thank "NIT Robocon Studio".

## EAGLE design SurfaceRX/eagle/surfaceRX.brd

Parts:
0: 120; MINI_MELF-0102W
C1, C9, C10, C11, C23, C26, C27, C32, C33, C34, C35, C36, C37: 0.1u; C0402
C2, C3, C6, C7, C12, C13, C14, C15, C17, C18, C19, C20: 0.01u; C0402
C4, C16, C24, C28, C29, C30, C31: 0.1uF; C0603K
C5, C8, C21, C22: 22p; C0603K
C25: 47u; C3225
C40, C43: 10u; C0603K
C41, C42, C45, C46, C47: 0.1u; C0603K
C44: 0.1uu; C0603K
D1, D14: ES2D; SMB
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13: PMLL4150; SOD80C
IC1, IC3: TCM809; SOT23B-3
IC2, IC4: FT232RL; SSOP28
IC5: ADM3202ARN; SO16
IC6, IC7: PIC24FJ64GA004; TQFP44
JP1, JP8: PINHD-1X6; 1X06
JP2, JP3: PINHD-1X2; 1X02
JP5, JP6: PINHD-1X5; 1X05
JP7: PINHD-2X3; 2X03
LED0, LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16: LEDSML0805; SML0805
MCU1: R5F562N8BDFP; LQFP100
Q4: MOSFET-NREFLOW; SOT23
R1, R3, R4, R9, R11, R12, R13, R32, R35, R37, R38, R64, R65, R72: 0; MINI_MELF-0102W
R2: 120; MINI_MELF-0102W
R5, R6, R8, R14, R36: 4.7k; MINI_MELF-0102W
R7, R27, R28, R29, R30, R34, R49, R50, R51, R52, R57, R58, R60, R61, R62, R63, R68, R69, R70, R71: 1k; MINI_MELF-0102W
R10, R33, R43, R44, R45, R46, R47, R48, R53, R54, R55, R56, R59, R67: 10k; MINI_MELF-0102W
R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26: 200; MINI_MELF-0102W
R31: 10k; CA6V
R39, R40: 15k; MINI_MELF-0102W
R41, R42: 22; MINI_MELF-0102W
R_MD2, R_MD3, R_MD4: R-US_MELF0102W; MINI_MELF-0102W
R_NMI: R-US_MELF0102W; MINI_MELF-0102W
R_XCIN: R-US_MELF0102W; MINI_MELF-0102W
S6: TL32YO; TL3XYO
SG2: AL60P
SJ1, SJ4, SJ5: SJ
U$1, U$14, U$15, U$24, U$27, U$29, U$30, U$80: GHTOP4
U$2, U$3, U$5, U$10, U$11, U$12, U$13, U$16, U$31, U$32, U$33, U$34, U$35, U$36, U$37, U$38, U$39, U$40, U$41, U$42, U$43, U$44, U$45, U$46, U$47, U$48, U$49, U$50, U$51, U$52, U$53, U$54, U$55, U$56, U$58, U$59, U$76, U$78: FB1.25MM; 2012
U$4: R5F5631FDDFP; LQFP100
U$6, U$8: TSHA-T-2
U$9: MUSB-5BF02AS-N
U$17, U$19, U$64: MCP2562
U$18, U$20, U$21, U$25: RJ45
U$22, U$23: 2DC-G213-B66
U$26: NJM2845DL1; TO-252-3-L1
U$28, U$57: DM3AT-SF-PEJ
U$61, U$62: FA238V
U$63: USB-TYPEB
U$65: SC1602BBWB_PAD
U$66, U$69, U$70, U$71, U$72, U$73, U$74, U$81: TVBP06
U$67, U$75, U$77: USB_A
U$68: 3STATE; SOT23-5
U$79: KHS42
U$82: SSSS2
X2: 057-016-1
X3: 057-010-1

Connections:
621-AN0: MCU1.95 (AN0), U$54.2
621-AN1: MCU1.93 (AN1), U$53.2
621-AN2: MCU1.92 (AN2), U$52.2
621-AN3: MCU1.91 (AN3), U$51.2
621-AN4: MCU1.90 (AN4), U$50.2
621-AN5: MCU1.89 (AN5), U$49.2
621-AN6: MCU1.88 (AN6), U$48.2
621-AN7: MCU1.87 (AN7), U$47.2
621-CRX0: MCU1.17 (P33/MTIOC0D), U$64.4 (RXD)
621-CTX0: MCU1.18 (P32/MTIOC0C), U$64.1 (TXD)
621-EXTAL: C22.1, MCU1.13 (EXTAL), U$62.1
621-MD0: MCU1.7 (MD0), R8.2
621-MTCLKA-B: MCU1.46 (PC6/MTCLKA-B), U$16.2
621-MTCLKA-B-C: C20.1, D12.A, R25.1, U$16.1
621-MTCLKB-B: MCU1.45 (PC7/MTCLKB-B), U$31.2
621-MTCLKB-B-C: C19.1, D13.A, R26.1, U$31.1
621-MTCLKC-B: MCU1.48 (PC4/MTCLKC-B), U$12.2
621-MTCLKC-B-C: C18.1, D10.A, R23.1, U$12.1
621-MTCLKD-B: MCU1.47 (PC5/MTCLKD-B), U$13.2
621-MTCLKD-B-C: C15.1, D11.A, R24.1, U$13.1
621-MTCLKE-A: MCU1.50 (PC2/MTCLKE-A), U$10.2
621-MTCLKE-A-C: C7.1, D8.A, R17.1, U$10.1
621-MTCLKF-A: MCU1.49 (PC3/MTCLKF-A), U$11.2
621-MTCLKF-A-C: C6.1, D9.A, R22.1, U$11.1
621-MTCLKG-A: MCU1.52 (PC0/MTCLKG-A), U$3.2
621-MTCLKG-A-C: C3.1, D6.A, R15.1, U$3.1
621-MTCLKH-A: MCU1.51 (PC1/MTCLKH-A), U$5.2
621-MTCLKH-A-C: C2.1, D7.A, R16.1, U$5.1
621-PA2: LED14.A, MCU1.68 (PA2/MTIOC6C)
621-PA3: LED13.A, MCU1.67 (PA3/MTIOC6D)
621-PA4: LED7.A, MCU1.66 (PA4/MTIOC7A)
621-PA5: LED6.A, MCU1.65 (PA5/MTIOC7B)
621-PA6: LED5.A, MCU1.64 (PA6/MTIOC8A)
621-PA7: LED4.A, MCU1.63 (PA7/MTIOC8B)
621-PB4: MCU1.56 (PB4/MTIOC10A/MTCLKE-B), R48.2, U$79.4
621-PB5: MCU1.55 (PB5/MTIOC10C/MTCLKF-B), R47.2, U$79.3
621-PB6: MCU1.54 (PB6/MTIOC10B), R46.1, U$79.2
621-PB7: MCU1.53 (PB7/MTIOC10D), R45.1, U$79.1
621-PD0: MCU1.86 (PD0), R60.2, U$81.2
621-PD1: MCU1.85 (PD1), R61.2, U$74.2
621-PD2: MCU1.84 (PD2), R62.2, U$73.2
621-PD3: MCU1.83 (PD3), R63.2, U$72.2
621-RESET: MCU1.10 (!RES), R36.2, U$8.A, U$8.B
621-RXD0: IC5.12 (R1OUT), MCU1.27 (P21/RXD0)
621-RXD1: IC2.1 (TXD), MCU1.20 (P30/MTIOC4B-A/RXD1)
621-RXD2-B: IC7.2 (RC6), MCU1.42 (P52)
621-RXD3: JP8.1, MCU1.23 (P25/MTCLKB-A)
621-TXD0: IC5.11 (T1IN), MCU1.28 (P20/TXD0)
621-TXD1: MCU1.22 (P26/MTIOC2A/TXD1), R37.2
621-TXD2-B: IC7.3 (RC7), MCU1.44 (P50)
621-TXD3: JP8.2, MCU1.25 (P23/MTCLKD-A)
621-USB0_DM_I: MCU1.36 (USB0_DM), R42.2
621-USB0_DP_I: MCU1.37 (USB0_DP), R41.2
621-VCL: C1.2, MCU1.5 (VCL)
621-XCIN: MCU1.8 (XCIN), R14.2
621-XTAL: C21.2, MCU1.11 (XTAL), U$62.3
631-AN000: U$4.95 (P40/AN000), U$33.2
631-AN001: U$4.93 (P41/AN001), U$34.2
631-AN002: U$4.92 (P42/AN002), U$35.2
631-AN003: U$4.91 (P43/AN003), U$36.2
631-AN004: U$4.90 (P44/AN004), U$37.2
631-AN005: U$4.89 (P45/AN005), U$38.2
631-AN006: U$4.88 (P46/AN006), U$39.2
631-AN007: U$4.87 (P47/AN007), U$40.2
631-AN008: U$4.86 (PD0/AN008), U$41.2
631-AN009: U$4.85 (PD1/MTIOC4B/CTX0/AN009), U$42.2
631-AN010: U$4.84 (PD2/MTIOC4D/CRX0/AN010), U$43.2
631-AN011: U$4.83 (PD3/AN011), U$44.2
631-AN012: U$4.82 (PD4/AN012), U$45.2
631-AN013: U$4.81 (PD5/AN013), U$46.2
631-CRX0: U$4.17 (P33/MTIOC0D/RXD6/RXD0/CRX0), U$19.4 (RXD)
631-CRX1: U$4.39 (P55/MTIOC4D/CRX1), U$17.4 (RXD)
631-CTX0: U$4.18 (P32/MTIOC0C/TXD6/TXD0/CTX0), U$19.1 (TXD)
631-CTX1: U$4.40 (P54/MTIOC4B/CTX1), U$17.1 (TXD)
631-EXTAL: C8.1, U$4.13 (P36/EXTAL), U$61.1
631-MD/621-MD1: LED12.C, MCU1.6 (MD1), SJ4.2, U$4.7 (MD/FINED), U$68.4 (O)
631-MISOA: R4.1, U$4.63 (PA7)
631-MISOB: MCU1.71 (PE7/IRQ7), U$1.4, U$4.71 (PE7/AN5)
631-MOSIA: U$4.64 (PA6/MTCLKB), U$28.3 (DI)
631-MOSIB: MCU1.72 (PE6/IRQ6-A), U$1.3, U$4.72 (PE6/AN4)
631-MTCLKA: U$4.32 (P14/MTIOC3A/MTCLKA/CTX1), U$32.2
631-MTCLKA-C: C13.1, D4.A, R18.1, U$32.1
631-MTCLKB: U$4.31 (P15/MTIOC0B/MTCLKB/RXD1/SCK3), U$55.2
631-MTCLKB-C: C12.1, D5.A, R19.1, U$55.1
631-MTCLKC: U$4.48 (PC4/MTIOC3D/MTCLKC/SCK5), U$56.2
631-MTCLKC-C: C17.1, D2.A, R20.1, U$56.1
631-MTCLKD: U$4.47 (PC5/MTIOC3B/MTCLKD/SCK8), U$59.2
631-MTCLKD-C: C14.1, D3.A, R21.1, U$59.1
631-NMI: R_NMI.2, U$4.15 (P35/NMI)
631-P17: U$4.29 (P17/MTIOC3A/MTIOC3B/SCK1/TXD3), U$57.2 (-CS)
631-PA0: U$4.70 (PA0/MTIOC4A), U$65.11 (DB4)
631-PA1: U$4.69 (PA1/MTIOC0B/MTCLKC/SCK5), U$65.12 (DB5)
631-PA2: U$4.68 (PA2/RXD5), U$65.13 (DB6)
631-PA3: U$4.67 (PA3/MTIOC0D/MTCLKD/RXD5), U$65.14 (DB7)
631-PB0: U$4.61 (PB0/RXD6), U$65.4 (RS)
631-PB1: U$4.59 (PB1/MTIOC0C/MTIOC4C/TXD6), U$65.6 (E)
631-PB2: LED0.A, U$4.58 (PB2)
631-PB3: LED1.A, U$4.57 (PB3/MTIOC0A/MTIOC4A/SCK6)
631-PB4: LED2.A, U$4.56 (PB4)
631-PB5: LED3.A, U$4.55 (PB5/MTIOC2A/MTIOC1B/SCK9)
631-PB6: LED15.A, U$4.54 (PB6/MTIOC3D/RXD9)
631-PB7: LED16.A, U$4.53 (PB7/MTIOC3B/TXD9)
631-PC0: Q4.1 (G), R43.2, U$4.52 (PC0/MTIOC3C)
631-PD6: R53.2, U$4.80 (PD6/AN6), U$71.2
631-PD7: R54.2, U$4.79 (PD7/AN7), U$70.2
631-PE1: R55.2, U$4.77 (PE1/MTIOC4C/TXD12/ANEX1), U$69.2
631-PE2: R56.2, U$4.76 (PE2/MTIOC4A/RXD12/AN0), U$66.2
631-RESET: R6.2, SJ1.1, U$4.10 (RES#), U$6.A, U$6.B
631-RSPCKA: R35.1, U$4.65 (PA5)
631-RSPCKB: MCU1.73 (PE5/IRQ5), U$1.2, U$4.73 (PE5/MTIOC4C/MTIOC2B/AN3)
631-RXD0: R33.1, U$4.27 (P21/MTIOC1B/RXD0), U$57.7 (DO)
631-RXD1: JP7.3, U$4.20 (P30/TDI/MTIOC4B/RXD1)
631-RXD5: JP1.1, U$4.50 (PC2/MTIOC4B/TCLKA/RXD5)
631-SCK0: R72.1, U$4.26 (P22/MTIOC3B/MTCLKC/SCK0)
631-SSLA0: U$4.66 (PA4/MTCLKA/TXD5), U$28.2 (-CS)
631-SSLB0: MCU1.74 (PE4), U$4.74 (PE4/MTIOC4D/MTIOC1A/AN2)
631-SSLB1: U$1.1, U$4.78 (PE0/SCK12/ANEX0)
631-TXD0: U$4.28 (P20/MTIOC1A/TXD0), U$57.3 (DI)
631-TXD1: JP7.4, U$4.22 (P26/TDO/MTIOC2A/TXD1)
631-TXD5: JP1.2, U$4.49 (PC3/MTIOC4D/TCLKB/TXD5)
631-VCL: C4.1, U$4.5 (VCL)
631-XTAL: C5.2, U$4.11 (P37/XTAL), U$61.3
+3V3: C24.1, C25.1, C29.1, C33.2, C35.2, C36.2, C41.2, C42.2, C44.2, C45.2, C46.1, C47.2, IC1.3 (VCC), IC3.3 (VCC), IC5.16 (VCC), IC6.10 (RB12), IC6.17 (AVDD), IC6.28 (VDD), IC6.40 (VDD), IC7.10 (RB12), IC7.17 (AVDD), IC7.28 (VDD), IC7.40 (VDD), JP1.5, JP5.4, JP6.4, JP8.5, MCU1.1 (VCC), MCU1.14 (VCC), MCU1.29 (PLLVCC), MCU1.30 (P16/USB0_VBUS), MCU1.35 (VCC_USB), MCU1.60 (VCC), MCU1.96 (VREFH), MCU1.97 (AVCC), R5.1, R7.2, R8.1, R10.2, R14.1, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R33.2, R34.2, R39.1, R40.1, R44.2, R45.2, R46.2, R47.1, R48.1, R53.1, R54.1, R55.1, R56.1, R57.2, R58.2, R59.2, R60.1, R61.1, R62.1, R63.1, R_MD3.2, R_MD4.1, R_NMI.1, U$2.2, U$4.1 (VREFH), U$4.6 (VBATT), U$4.14 (VCC), U$4.35 (VCC_USB)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
CANH0: JP3.1, R65.1, U$20.P$5 (5), U$64.7 (CANH)
CANH1: 0.1, R11.2, U$17.7 (CANH), U$25.P$5 (5)
CANL0: R2.2, U$19.6 (CANL), U$20.P$4 (4), U$21.P$4 (4), U$64.6 (CANL)
CANL1: R3.1, U$17.6 (CANL), U$18.P$4 (4), U$25.P$4 (4)
CTS-RTS0: JP1.3, JP1.4
CTS-RTS1: JP8.3, JP8.4
CTS/RTS-631: IC6.4 (RC8), IC6.5 (RC9)
DM: IC2.16 (USBDM), U$63.2 (D-)
DM621: IC7.9 (RB11), U$77.2 (D-)
DM631: IC6.9 (RB11), U$75.2 (D-)
DP: IC2.15 (USBDP), U$63.3 (D+)
DP621: IC7.8 (RB10), U$77.3 (D+)
DP631: IC6.8 (RB10), U$75.3 (D+)
GND: C1.1, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.1, C24.2, C25.2, C26.1, C27.1, C28.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.2, C47.1, IC1.1 (GND), IC2.7 (GND), IC2.18 (GND), IC2.21 (GND), IC2.25 (GND), IC2.26 (TEST), IC3.1 (GND), IC4.7 (GND), IC4.18 (GND), IC4.21 (GND), IC4.25 (GND), IC4.26 (TEST), IC5.15 (GND), IC6.6 (DISVREG), IC6.16 (AVSS), IC6.29 (VSS), IC6.39 (VSS), IC7.6 (DISVREG), IC7.16 (AVSS), IC7.29 (VSS), IC7.39 (VSS), JP1.6, JP5.3, JP6.3, JP8.6, MCU1.2 (EMLE), MCU1.3 (VSS), MCU1.4 (MDE), MCU1.12 (VSS), MCU1.31 (PLLVSS), MCU1.38 (VSS_USB), MCU1.62 (VSS), MCU1.94 (VREFL), MCU1.99 (AVSS), Q4.2 (S), R27.2, R28.2, R29.2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
MODE_SW_EN: R_MD2.2, SJ5.2, U$68.1 (OE)
unnamed: R4.2, R10.1, U$28.7 (DO)
unnamed: U$2.1, U$28.4 (VDD)
unnamed: R31.S, U$65.3 (VO)
unnamed: LED12.A, R_MD3.1
unnamed: R_XCIN.2, U$4.8 (XCIN)
unnamed: IC3.2 (!RES), R6.1
unnamed: R1.1, U$18.P$1 (1), U$18.P$2 (2), U$18.P$3 (3)
unnamed: R11.1, U$18.P$5 (5)
unnamed: R35.2, U$28.5 (CLK)
unnamed: R72.2, U$57.5 (CLK)
unnamed: IC4.16 (USBDM), U$9.2 (D-)
unnamed: IC4.15 (USBDP), U$9.3 (D+)
unnamed: C9.2, IC4.4 (VCCIO), IC4.17 (3V3OUT)
unnamed: IC4.5 (RXD), R9.1
unnamed: JP2.2, R3.2
unnamed: R12.1, U$25.P$1 (1), U$25.P$2 (2), U$25.P$3 (3)
unnamed: D2.C, U$15.3
unnamed: R13.1, U$21.P$5 (5)
unnamed: D3.C, U$15.4
unnamed: D5.C, U$14.4
unnamed: D4.C, U$14.3
unnamed: R32.1, U$21.P$1 (1), U$21.P$2 (2), U$21.P$3 (3)
unnamed: JP3.2, R2.1
unnamed: S6.2, U$22.1, U$23.1
unnamed: MCU1.15 (P35/NMI), R5.2
unnamed: D7.C, U$24.4
unnamed: D6.C, U$24.3
unnamed: D8.C, U$27.3
unnamed: D9.C, U$27.4
unnamed: D11.C, U$29.4
unnamed: D10.C, U$29.3
unnamed: D12.C, U$30.3
unnamed: D13.C, U$30.4
unnamed: LED4.C, R27.1
unnamed: LED5.C, R28.1
unnamed: LED6.C, R29.1
unnamed: LED7.C, R30.1
unnamed: R38.1, U$20.P$1 (1), U$20.P$2 (2), U$20.P$3 (3)
unnamed: U$57.4 (VDD), U$58.1
unnamed: R32.2, R64.1
unnamed: 0.2, JP2.1
unnamed: R13.2, R65.2, U$19.7 (CANH)
unnamed: LED13.C, R71.1
unnamed: U$47.1, X3.3
unnamed: U$48.1, X3.4
unnamed: IC1.2 (!RES), R36.1
unnamed: U$49.1, X3.5
unnamed: U$50.1, X3.6
unnamed: U$51.1, X3.7
unnamed: U$52.1, X3.8
unnamed: C23.2, IC2.4 (VCCIO), IC2.17 (3V3OUT)
unnamed: IC2.5 (RXD), R37.1
unnamed: IC5.14 (T1OUT), U$80.4
unnamed: C43.2, IC7.7 (VDDCORE)
unnamed: U$53.1, X3.9
unnamed: U$54.1, X3.10
unnamed: U$33.1, X2.3
unnamed: U$34.1, X2.4
unnamed: U$35.1, X2.5
unnamed: U$36.1, X2.6
unnamed: U$37.1, X2.7
unnamed: U$38.1, X2.8
unnamed: U$39.1, X2.9
unnamed: U$40.1, X2.10
unnamed: U$41.1, X2.11
unnamed: U$42.1, X2.12
unnamed: U$43.1, X2.13
unnamed: U$44.1, X2.14
unnamed: U$45.1, X2.15
unnamed: U$46.1, X2.16
unnamed: LED14.C, R70.1
unnamed: C28.2, IC5.6 (V-)
unnamed: C29.2, IC5.2 (V+)
unnamed: C30.1, IC5.1 (C1+)
unnamed: Q4.3 (D), SG2.2
unnamed: C31.1, IC5.4 (C2+)
unnamed: LED0.C, R49.1
unnamed: R67.2, U$4.45 (PC7/MTIOC3A/MTCLKB/TXD8)
unnamed: LED1.C, R50.1
unnamed: C31.2, IC5.5 (C2-)
unnamed: C30.2, IC5.3 (C1-)
unnamed: LED2.C, R51.1
unnamed: LED3.C, R52.1
unnamed: IC5.13 (R1IN), U$80.3
unnamed: LED10.C, R7.1
unnamed: LED11.C, R34.1
unnamed: IC7.15 (RB15), LED10.A
unnamed: U$68.2 (I), U$82.2, U$82.5
unnamed: IC7.14 (RB14), LED11.A
unnamed: U$77.1 (VBUS), U$78.1
unnamed: LED15.C, R68.1
unnamed: LED16.C, R69.1
unnamed: LED8.C, R57.1
unnamed: LED9.C, R58.1
unnamed: IC6.15 (RB15), LED8.A
unnamed: IC6.14 (RB14), LED9.A
unnamed: C40.2, IC6.7 (VDDCORE)
unnamed: U$75.1 (VBUS), U$76.1
unnamed: R_MD4.2, U$82.3, U$82.6
NMCLR-621: IC7.18 (!MCLR), JP6.5, R44.1
NMCLR-631: IC6.18 (!MCLR), JP5.5, R59.1
PGEC1-621: IC7.22 (RB1), JP6.1
PGEC1-631: IC6.22 (RB1), JP5.1, SJ4.1
PGED1-621: IC7.21 (RB0), JP6.2
PGED1-631: IC6.21 (RB0), JP5.2, SJ5.1
RB9: IC6.1 (RB9), SJ1.2
RESET-621: IC7.1 (RB9)
RTS/CTS-621: IC7.4 (RC8), IC7.5 (RC9)
RXD1: IC4.1 (TXD), JP7.5
SBDBT1-RX: IC6.3 (RC7), JP7.2
SBDBT1-TX: IC6.2 (RC6), JP7.1
TXD1: JP7.6, R9.2
USB0_DM: R39.2, R42.1, U$67.2 (D-)
USB0_DP: R40.2, R41.1, U$67.3 (D+)
VBUS0: C10.2, C11.2, D1.C, IC4.20 (VCC), U$9.1 (VBUS)
VBUS1: C26.2, C27.2, D14.C, IC2.20 (VCC), U$63.1 (VBUS)
VCC: C16.1, C32.2, C34.2, C37.2, D1.A, D14.A, IC6.42 (RB6), IC7.42 (RB6), R1.2, R12.2, R31.A, R38.2, R64.2, S6.1 (O), SG2.1, U$14.1, U$15.1, U$17.3 (VDD), U$19.3 (VDD), U$24.1, U$26.1 (IN), U$27.1, U$29.1, U$30.1, U$64.3 (VDD), U$65.1 (VDD), U$67.1 (VBUS), U$76.2, U$78.2

Notes on the sheet:
MDE: LOW = little endian
EMLE: LOW = emulate OFF
NMI: HIGH = none maskable interrupt none
ADC
XTAL
RESET
BOOT
SD card
SPI
ENCODER
Bluetooth-Module
BUTTON
LED
LCD
CAN
SUPPLY
BUZZER
GYRO
USB
Wireless Mode
PIC24FJ64GB004のつもり
USB_HOST
DIP

Board: 2 copper layers, 150.0 x 100.0 mm, 256 parts (82 on the bottom side), 254 nets.
