# Repository CC-WO/nitrobocon (continued)

## EAGLE design NHK2016Mother/eagle/NHK2016mother_rev3/NHK2016mother.brd

Parts:
3V3, 5V: 1,6/0,8
C1, C3, C17, C24: 0.1uF; C0603K
C2, C12, C13, C14: 0.01u; C0402
C4, C6, C25: 47u; C3225
C5, C8: 22p; C0603K
C7, C15, C19, C20, C21, C22, C23, C26, C27, C28, C34, C35: 0.1u; C0402
C9, C10: 15p; C0603K
C11, C16: 47p; C0603K
C18: 10u; C0402
C40: 10u; C0603K
C41, C42, C46: 0.1u; C0603K
D1: ES2D; SMB
D2, D3, D9, D10: DIODESOD-523; SOD-523
DAC: DAC; 1,6/0,8
GND, GND0: 1,6/0,8
IC1: TCM809; SOT23B-3
IC6: PIC24FJ64GA004; TQFP44
J1: JACK-PLUG1; SPC4078
JP1, JP2, JP4, JP6: PINHD-1X2; 1X02
JP3: PINHD-1X6; 1X06
JP5: PINHD-1X5; 1X05
JP7: PINHD-2X3; 2X03
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11: LEDSML0805; SML0805
Q1, Q2, Q3, Q4: MOSFET-NREFLOW; SOT23
R1, R2: 27; MINI_MELF-0102W
R3, R4, R41: 120; MINI_MELF-0102W
R5, R6, R7, R12, R15, R28, R33, R34, R38, R42, R44, R45, R46, R47: R-US_MELF0102W; MINI_MELF-0102W
R8, R9, R10, R11, R16, R17, R23, R24, R27, R30, R31, R32, R43, R48, R49, R50, R59: 10k; MINI_MELF-0102W
R13, R14: 15k; MINI_MELF-0102W
R18, R19, R20, R21: 200; MINI_MELF-0102W
R22, R29: 22; MINI_MELF-0102W
R25, R26, R57, R58: 1k; MINI_MELF-0102W
R40: 1.33k; MINI_MELF-0102W
R_MD2, R_MD3, R_MD4: R-US_MELF0102W; MINI_MELF-0102W
R_NMI: 10k; MINI_MELF-0102W
S1, S2, S3, S4, S5: 10-XX; B3F-10XX
S6: TL32YO; TL3XYO
SG2: AL60P
SJ1, SJ4, SJ5: SJ
U$1: R5F5631FDDFP; LQFP100
U$2: FT231X; SSOP20
U$3, U$17: MCP2562
U$4, U$5, U$9, U$27: RJ45
U$6, U$7, U$8, U$14: FB1.25MM 330; 2012
U$10: TERMINAL
U$11: OKL_T6_W12
U$12: FC-255
U$13, U$33, U$34, U$35, U$36, U$37, U$38, U$39, U$40, U$41, U$42, U$43, U$44, U$45, U$46, U$76: FB1.25MM; 2012
U$26: NJM2845DL1; TO-252-3-L1
U$32: MPU9150
U$58: EC12PLRGBSDVBF
U$61: FA238V
U$68: 3STATE; SOT23-5
U$82: SSSS2
USB: MINI-USB_4P-85-32004-10X; 85-32004-10X
X1: 057-014-1
X2: 057-016-1
X3: 057-010-1
X4, X5, X6, X7: XA-4PNORMAL; XA-4P
X8: XA-6P
X10, X25: PN87520-S

Connections:
+3V3: 3V3.1, C15.2, C17.1, C22.2, C23.2, C24.1, C25.1, C26.1, C27.2, C28.1, C35.2, C41.2, C42.2, C46.1, IC1.3 (VCC), IC6.10 (RB12), IC6.17 (AVDD), IC6.28 (VDD), IC6.40 (VDD), JP3.5, JP5.4, R8.1, R10.1, R11.1, R17.1, R18.2, R19.2, R20.2, R21.2, R23.1, R24.2, R25.1, R26.1, R30.1, R31.1, R32.2, R42.1, R44.2, R57.2, R58.2, R59.2, R_MD3.2, R_MD4.1, R_NMI.1, U$1.1 (VREFH), U$1.6 (VBATT), U$1.14 (VCC), U$1.35 (VCC_USB), U$1.60 (VCC), U$1.96 (VREFH0), U$1.97 (AVCC0), U$3.5 (VIO), U$17.5 (VIO), U$26.3 (OUT), U$32.1 (VDD), U$32.2 (VLOGIC), U$58.5 (LED_A), U$68.5 (V), X2.1, X3.1, X5.4, X7.4, X8.6
AN000: U$1.95 (P40/AN000), U$33.2
AN001: U$1.93 (P41/AN001), U$34.2
AN002: U$1.92 (P42/AN002), U$35.2
AN003: U$1.91 (P43/AN003), U$36.2
AN004: U$1.90 (P44/AN004), U$37.2
AN005: U$1.89 (P45/AN005), U$38.2
AN006: U$1.88 (P46/AN006), U$39.2
AN007: U$1.87 (P47/AN007), U$40.2
AN008: U$1.86 (PD0/AN008), U$41.2
AN009: U$1.85 (PD1/MTIOC4B/CTX0/AN009), U$42.2
AN010: U$1.84 (PD2/MTIOC4D/CRX0/AN010), U$43.2
AN011: U$1.83 (PD3/AN011), U$44.2
AN012: U$1.82 (PD4/AN012), U$45.2
AN013: U$1.81 (PD5/AN013), U$46.2
CRX0: U$1.17 (P33/MTIOC0D/RXD6/RXD0/CRX0), U$17.4 (RXD)
CRX1: U$1.39 (P55/MTIOC4D/CRX1), U$3.4 (RXD)
CTS-RTS0: JP3.3, JP3.4
CTS/RTS: IC6.4 (RC8), IC6.5 (RC9)
CTX0: U$1.18 (P32/MTIOC0C/TXD6/TXD0/CTX0), U$17.1 (TXD)
CTX1: U$1.40 (P54/MTIOC4B/CTX1), U$3.1 (TXD)
DM: C11.2, R1.2, USB.2
DP: C16.2, R2.2, USB.3
EMLE: JP6.2, R30.2, U$1.2 (EMLE), X1.4
ENC-A: R42.2, U$1.55 (PB5/MTIOC2A/MTIOC1B/SCK9), U$58.8 (A)
ENC-B: R44.1, U$1.53 (PB7/MTIOC3B/TXD9), U$58.6 (B)
ENC-BLUE: Q3.1 (G), R49.1, U$1.51 (PC1/MTIOC3A/TCLKA/RXD5)
ENC-GREEN: Q2.1 (G), R48.1, U$1.52 (PC0/MTIOC3C)
ENC-RED: Q1.1 (G), R50.1, U$1.57 (PB3/MTIOC0A/MTIOC4A/SCK6)
ENC-SW: R38.2, U$1.56 (PB4), U$58.3 (SW)
EXTAL: C8.1, U$1.13 (P36/EXTAL), U$61.1
FT231X-RXD: JP7.3, U$2.4 (RXD)
FT231X-TXD: JP7.4, U$2.20 (TXD)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.1, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.1, C16.1, C17.2, C18.2, C19.2, C20.1, C21.1, C22.1, C23.1, C24.2, C25.2, C27.1, C28.2, C34.1, C35.1, C40.1, C41.1, C42.1, C46.2, GND.1, GND0.1, IC1.1 (GND), IC6.6 (DISVREG), IC6.16 (AVSS), IC6.29 (VSS), IC6.39 (VSS), J1.1, J1.2, JP3.6, JP4.2, JP5.3, JP6.1, LED1.C, LED2.C, LED3.C, LED4.C, LED6.C, LED7.C, LED10.C, LED11.C, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R9.1, R13.1, R14.1, R27.1, R38.1, R40.2, R43.1, R48.2, R49.2, R50.2, R_MD2.1, S1.3, S1.4 (P1), S2.3, S2.4 (P1), S3.3, S3.4 (P1), S4.3, S4.4 (P1), S5.3, S5.4 (P1), U$1.3 (VREFL)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
IMU_INT: U$1.30 (P16/MTIOC3C/MTIOC3D/TXD1/RXD3), U$32.8 (INT)
MD: LED5.C, SJ4.2, U$1.7 (MD/FINED), U$68.4 (O), X1.7
MISOB: U$1.71 (PE7/AN5), X8.1
MODE_SW_EN: R_MD2.2, SJ5.2, U$68.1 (OE)
MOSIB: U$1.72 (PE6/AN4), X8.2
MTCLKA: U$1.32 (P14/MTIOC3A/MTCLKA/CTX1), U$6.2
MTCLKA_I: C2.1, D2.A, R20.1, U$6.1
MTCLKB: U$1.31 (P15/MTIOC0B/MTCLKB/RXD1/SCK3), U$14.2
MTCLKB_I: C14.1, D3.A, R21.1, U$14.1
MTCLKC: U$1.48 (PC4/MTIOC3D/MTCLKC/SCK5), U$7.2
MTCLKC_I: C13.1, D9.A, R18.1, U$7.1
MTCLKD: U$1.47 (PC5/MTIOC3B/MTCLKD/SCK8), U$8.2
MTCLKD_I: C12.1, D10.A, R19.1, U$8.1
MTIOC4A: Q4.1 (G), R43.2, U$1.76 (PE2/MTIOC4A/RXD12/AN0)
unnamed: R1.1, U$2.12 (USBDM)
unnamed: R_NMI.2, U$1.15 (P35/NMI)
unnamed: LED5.A, R_MD3.1
unnamed: R2.1, U$2.11 (USBDP)
unnamed: U$2.1 (DTR#), U$2.7 (DSR#)
unnamed: U$2.2 (RTS#), U$2.9 (CTS#)
unnamed: JP2.1, R3.2
unnamed: JP1.2, U$3.7 (CANH), U$4.P$5 (5), U$5.P$5 (5)
unnamed: R4.1, U$3.6 (CANL), U$4.P$4 (4), U$5.P$4 (4)
unnamed: JP1.1, R4.2
unnamed: R5.2, U$1.77 (PE1/MTIOC4C/TXD12/ANEX1)
unnamed: R6.2, U$1.78 (PE0/SCK12/ANEX0)
unnamed: R7.2, U$1.80 (PD6/AN6)
unnamed: JP2.2, U$9.P$5 (5), U$17.7 (CANH), U$27.P$5 (5)
unnamed: R3.1, U$9.P$4 (4), U$17.6 (CANL), U$27.P$4 (4)
unnamed: LED1.A, R5.1
unnamed: IC1.2 (!RES), R15.2
unnamed: LED2.A, R6.1
unnamed: LED3.A, R7.1
unnamed: R12.2, U$1.79 (PD7/AN7)
unnamed: LED4.A, R12.1
unnamed: LED7.A, R28.1
unnamed: R28.2, U$1.75 (PE3/MTIOC4B/AN1)
unnamed: DAC.1, U$1.100 (P05/DA1)
unnamed: D10.K (C), X6.1
unnamed: D9.K (C), X6.2
unnamed: D2.K (C), X4.2
unnamed: D3.K (C), X4.1
unnamed: LED6.A, R41.2
unnamed: R40.1, U$11.TRIM
unnamed: U$2.15 (VCC), U$13.2
unnamed: C1.1, U$1.5 (VCL)
unnamed: C20.2, R16.1, U$2.3 (VCCIO), U$2.13 (3V3OUT)
unnamed: C21.2, R16.2, U$2.14 (RESET#)
unnamed: C18.1, C19.1, D1.C, U$13.1, USB.1
unnamed: R14.2, R29.1, X25.3
unnamed: R13.2, R22.1, X25.2
unnamed: U$76.1, X10.1
unnamed: LED10.A, R33.1
unnamed: LED11.A, R34.1
unnamed: R33.2, U$1.58 (PB2)
unnamed: R34.2, U$1.29 (P17/MTIOC3A/MTIOC3B/SCK1/TXD3)
unnamed: U$33.1, X2.3
unnamed: U$34.1, X2.4
unnamed: U$35.1, X2.5
unnamed: U$36.1, X2.6
unnamed: U$37.1, X2.7
unnamed: U$38.1, X2.8
unnamed: U$39.1, X2.9
unnamed: U$40.1, X2.10
unnamed: U$41.1, X2.11
unnamed: U$42.1, X2.12
unnamed: U$43.1, X2.13
unnamed: U$44.1, X2.14
unnamed: U$45.1, X2.15
unnamed: U$46.1, X2.16
unnamed: Q4.3 (D), SG2.2
unnamed: Q1.3 (D), R45.1
unnamed: U$68.2 (I), U$82.2, U$82.5
unnamed: R45.2, U$58.1 (RED)
unnamed: R46.2, U$58.2 (GREEN)
unnamed: R47.2, U$58.4 (BLUE)
unnamed: Q2.3 (D), R46.1
unnamed: Q3.3 (D), R47.1
unnamed: LED8.C, R57.1
unnamed: LED9.C, R58.1
unnamed: IC6.15 (RB15), LED8.A
unnamed: IC6.14 (RB14), LED9.A
unnamed: C40.2, IC6.7 (VDDCORE)
unnamed: R_MD4.2, U$82.3, U$82.6
NMCLR: IC6.18 (!MCLR), JP5.5, R59.1
P22: R24.1, S5.1 (S), S5.2 (S1), U$1.26 (P22/MTIOC3B/MTCLKC/SCK0)
P23: R23.2, S4.1 (S), S4.2 (S1), U$1.25 (P23/MTIOC3D/MTCLKD/TXD3)
P24: R32.1, S3.1 (S), S3.2 (S1), U$1.24 (P24/MTIOC4A/MTCLKA/SCK3)
P25: R31.2, S2.1 (S), S2.2 (S1), U$1.23 (P25/MTIOC4C/MTCLKB/RXD3)
PA0: U$1.70 (PA0/MTIOC4A), X3.3
PA1: U$1.69 (PA1/MTIOC0B/MTCLKC/SCK5), X3.4
PA2: U$1.68 (PA2/RXD5), X3.5
PA3: U$1.67 (PA3/MTIOC0D/MTCLKD/RXD5), X3.6
PA4: U$1.66 (PA4/MTCLKA/TXD5), X3.7
PA5: U$1.65 (PA5), X3.8
PA6: U$1.64 (PA6/MTCLKB), X3.9
PA7: U$1.63 (PA7), X3.10
PB6: U$1.54 (PB6/MTIOC3D/RXD9)
PC7: R27.2, U$1.45 (PC7/MTIOC3A/MTCLKB/TXD8), X1.10
PGEC1: IC6.22 (RB1), JP5.1, SJ4.1
PGED1: IC6.21 (RB0), JP5.2, SJ5.1
PIC_DM: IC6.9 (RB11), X10.2
PIC_DP: IC6.8 (RB10), X10.3
RB9: IC6.1 (RB9), SJ1.2
RES#: R15.1, S1.1 (S), S1.2 (S1), SJ1.1, U$1.10 (RES#), X1.13
RSPCKB: U$1.73 (PE5/MTIOC4C/MTIOC2B/AN3), X8.3
RXD0: JP3.1, U$1.27 (P21/MTIOC1B/RXD0)
RXD1: IC6.2 (RC6), JP7.6, R17.2, U$1.20 (P30/TDI/MTIOC4B/RXD1), X1.11
RXD2: JP7.2, U$1.42 (P52/RXD2)
RXD5: U$1.50 (PC2/MTIOC4B/TCLKA/RXD5), X5.2
RXD6: U$1.61 (PB0/RXD6), X7.2
SCL0: R25.2, U$1.34 (P12/RXD2), U$32.3 (SCL)
SDA0: R26.2, U$1.33 (P13/MTIOC0B/TXD2), U$32.4 (SDA)
SSLB0: U$1.74 (PE4/MTIOC4D/MTIOC1A/AN2), X8.4
TCK: R8.2, U$1.21 (P27/TCK/MTIOC2B/SCK1), X1.1
TMS: R11.2, U$1.19 (P31/TMS/MTIOC4D), X1.9
TRST#: R9.2, U$1.16 (P34/MTIOC0A/SCK6/SCK0/USB0_DPRPD), X1.3
TXD0: JP3.2, U$1.28 (P20/MTIOC1A/TXD0)
TXD1: IC6.3 (RC7), JP7.5, R10.2, U$1.22 (P26/TDO/MTIOC2A/TXD1), X1.5
TXD2: JP7.1, U$1.44 (P50/TXD2)
TXD5: U$1.49 (PC3/MTIOC4D/TCLKB/TXD5), X5.1
TXD6: U$1.59 (PB1/MTIOC0C/MTIOC4C/TXD6), X7.1
USB0_DM: R22.2, U$1.36 (USB0_DM)
USB0_DP: R29.2, U$1.37 (USB0_DP)
VCC: 5V.1, C3.1, C6.2, C7.2, C34.2, D1.A, IC6.42 (RB6), R41.1, SG2.1, U$3.3 (VDD), U$4.P$1 (1), U$4.P$2 (2), U$4.P$3 (3), U$5.P$1 (1), U$5.P$2 (2), U$5.P$3 (3), U$9.P$1 (1), U$9.P$2 (2), U$9.P$3 (3), U$11.SENSE, U$11.VOUT, U$17.3 (VDD), U$26.1 (IN), U$27.P$1 (1), U$27.P$2 (2), U$27.P$3 (3), U$76.2, X1.8, X4.4, X6.4, X25.1
VIN1: J1.3, S6.2, U$10.P$1
VIN2: C4.2, JP4.1, S6.1 (O), U$11.VIN@0 (VIN), U$11.VIN@1 (VIN)
XCIN: C9.1, U$1.8 (XCIN), U$12.1
XCOUT: C10.1, U$1.9 (XCOUT), U$12.2
XTAL: C5.2, U$1.11 (P37/XTAL), U$61.3

Notes on the sheet:
USB_HOST
PIC24FJ64GB004のつもり
USB
hipower red led
3mA以上
コネクタのピン配置逆
Buzzer
GPIO
12bitADC
E1 Emulator
XTAL
RESET
UART
BUTTON
CAN
MPU9150
Bluetooth UART
USB HOST
ENCODER
Rotary ENCODER
SPI
SCI
Power Supply
Mode
Pickit

Board: 2 copper layers, 100.0 x 100.0 mm, 180 parts (59 on the bottom side), 163 nets.

## EAGLE design NHK2016Mother/eagle/NHK2016mother_rev4/NHK2016mother_rev4.brd

Parts:
3V3, 5V: 1,6/0,8
C1, C6, C7, C8, C9, C14, C15, C16, C17, C18, C19, C21, C25, C26, C28, C30, C31, C33: 0.1u; C0603K
C2, C3: 22p; C2012
C4, C5: 15p; C0603K
C10, C11, C12, C13: 0.01u; C0603K
C20: 47u; C3225
C22, C23: 47p; C0603K
C24, C29, C32, C34: 10u; C1608
C27: 1u; C0603K
D1, D2, D3, D4: DIODESOD-523; SOD-523
D5, D6, D7: ES2D; SMB
DAC: 1,6/0,8
FT231XS: FT231X; SSOP20
GNDPAD0, GNDPAD1: 1,6/0,8
IC1: TCM809; SOT23B-3
IC6: PIC24FJ64GA004; TQFP44
J1: JACK-PLUG1; SPC4078
JP1, JP2, JP3, JP5, JP6, JP9: PINHD-1X2; 1X02
JP4: PINHD-1X6; 1X06
JP7: PINHD-1X5; 1X05
JP8: PINHD-2X3; 2X03
LED1, LED2, LED3, LED4, LED5, LED9, LED10, LED11, LED12, LED13, LED14: LEDSML0805; SML0805
Q1, Q2, Q3, Q4: MOSFET-NREFLOW; SOT23
R1, R2, R3, R4, R5, R6, R8, R12, R19, R20, R22, R23, R24, R33, R51, R54: 10k; MINI_MELF-0102W
R7, R11, R25, R26, R27, R28, R34, R42, R43, R49, R50, R52, R53: 1k; MINI_MELF-0102W
R9, R10: 120; MINI_MELF-0102W
R15, R16, R17, R18: 200; MINI_MELF-0102W
R35: 2k; MINI_MELF-0102W
R40, R41: 27; MINI_MELF-0102W
R44, R45: 22; MINI_MELF-0102W
R46: 15k; MINI_MELF-0102W
R47: 30k; MINI_MELF-0102W
R48: 1.5k; MINI_MELF-0102W
S1, S2, S3, S4, S5: 10-XX; B3F-10XX
SG2: AL60P
SJ1, SJ2: SJ
U$1: R5F5631FDDFP; LQFP100
U$3: FC-255
U$4, U$5: MCP2562
U$8, U$9, U$10, U$11, U$18: FB1.25MM 330; 2012
U$12: RN42
U$13, U$14: M78AR033-0.5; M78AR033-0.5V
U$15: J320S-2P-L
U$16: PS-85S
U$17, U$21, U$23: NMR04; MNR04
U$22: ZX62R
U$24, U$25: MULTIPLEXER2CIR
U$58: EC12PLRGBSDVBF
U$76: FB1.25MM; 2012
U$82: SSSS2
X1: 057-014-1
X2, X12: XA-2P
X3: PN87520-S
X4, X5, X6, X7, X8: XA-4PNORMAL; XA-4P
X9: 057-010-1
X10: XA-6P
X11: 057-016-1
X13, X15, X16, X17: XA-3PL; XA-3P-L
X14: PN61729
XTAL1: FA-238V_CRYSTAL

Connections:
12V-: J1.1, J1.2, U$15.2, U$16.1, U$16.4
+3V3: 5V.1, C7.1, C9.1, C17.1, C26.1, C28.1, C30.2, C31.1, C33.1, C34.1, D6.A, IC1.3 (VCC), IC6.10 (RB12), IC6.17 (AVDD), IC6.28 (VDD), IC6.40 (VDD), JP4.5, JP7.2, LED11.A, LED14.A, R1.1, R3.2, R6.2, R12.2, R15.2, R16.2, R17.2, R18.2, R19.1, R20.1, R42.2, R43.2, R51.2, R52.1, R53.1, R54.2, U$1.1 (VREFH), U$1.6 (VBATT), U$1.14 (VCC), U$1.35 (VCC_USB), U$1.60 (VCC), U$1.96 (VREFH0), U$1.97 (AVCC0), U$4.5 (VIO), U$5.5 (VIO), U$12.11 (VDD), U$14.3 (+VOUT), U$21.2, U$21.4, U$21.6, U$21.8, U$23.2, U$23.4, U$23.6, U$23.8, U$24.8 (V+), U$25.8 (V+), U$58.5 (LED_A), X1.8, X4.1, X5.1, X6.1, X9.1, X10.1, X11.1
+5V: 3V3.1, C6.1, C8.1, C16.1, C29.1, D5.A, D7.A, IC6.42 (RB6), LED10.A, SG2.2, U$4.3 (VDD), U$5.3 (VDD), U$13.3 (+VOUT), U$76.2, X7.1, X8.1
+12V: C18.1, C19.1, C20.1, D5.C, D6.C, J1.3, LED5.A, U$13.1 (+VIN), U$14.1 (+VIN), U$15.1, X2.1, X12.1
AN000: U$1.95 (P40/AN000), X11.3
AN001: U$1.93 (P41/AN001), X11.4
AN002: U$1.92 (P42/AN002), X11.5
AN003: U$1.91 (P43/AN003), X11.6
AN004: U$1.90 (P44/AN004), X11.7
AN005: U$1.89 (P45/AN005), X11.8
AN006: U$1.88 (P46/AN006), X11.9
AN007: U$1.87 (P47/AN007), X11.10
AN008: U$1.86 (PD0/AN008), X11.11
AN009: U$1.85 (PD1/MTIOC4B/CTX0/AN009), X11.12
AN010: U$1.84 (PD2/MTIOC4D/CRX0/AN010), X11.13
AN011: U$1.83 (PD3/AN011), X11.14
AN012: U$1.82 (PD4/AN012), X11.15
AN013: U$1.81 (PD5/AN013), X11.16
BCLK: U$1.41 (P53/BCLK)
CANH0: R10.2, U$5.7 (CANH), X13.2, X15.2
CANH1: R9.1, U$4.7 (CANH), X16.2, X17.2
CANL0: JP3.1, U$5.6 (CANL), X13.3, X15.3
CANL1: JP2.1, U$4.6 (CANL), X16.3, X17.3
CRX0: U$1.17 (P33/MTIOC0D/RXD6/RXD0/CRX0), U$5.4 (RXD)
CRX1: U$1.39 (P55/MTIOC4D/CRX1), U$4.4 (RXD)
CTX0: U$1.18 (P32/MTIOC0C/TXD6/TXD0/CTX0), U$5.1 (TXD)
CTX1: U$1.40 (P54/MTIOC4B/CTX1), U$4.1 (TXD)
DA1: DAC.1, U$1.100 (P05/DA1)
EMLE: JP1.2, R3.1, U$1.2 (EMLE), X1.4
EXTAL: C3.1, U$1.13 (P36/EXTAL), XTAL1.3 (2)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.1, C11.1, C12.1, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C27.1, C28.2, C29.2, C30.1, C31.2, C32.2, C33.2, C34.2, FT231XS.6 (GND), FT231XS.16 (GND), GNDPAD0.1, GNDPAD1.1, IC1.1 (GND), IC6.6 (DISVREG), IC6.16 (AVSS), IC6.29 (VSS), IC6.39 (VSS), JP1.1, JP4.6, JP6.1, JP7.3, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R2.1, R4.1, R5.1, R8.1, R11.1, R25.1, R26.1, R27.1, R28.1, R33.1, R34.1, R47.2, R49.1, R50.1, S1.1 (S), S1.2 (S1), S2.1 (S), S2.2 (S1), S3.1 (S), S3.2 (S1), S4.1 (S), S4.2 (S1), S5.3, S5.4 (P1), U$1.3 (VREFL), U$1.12 (VSS), U$1.38 (VSS_USB), U$1.62 (VSS), U$1.94 (VREFL0)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
MD: R7.1, U$1.7 (MD/FINED), U$24.10 (COM1), X1.7
MDSW: U$24.9 (NC1), U$82.2, U$82.5
MISOB: U$1.71 (PE7/AN5), X10.6
MOSIB: U$1.72 (PE6/AN4), X10.5
MTCLKA: U$1.31 (P15/MTIOC0B/MTCLKB/RXD1/SCK3), U$10.2
MTCLKB/USBDPUPE: JP8.5, U$11.2
MTCLKC: U$1.48 (PC4/MTIOC3D/MTCLKC/SCK5), U$8.2
MTCLKD: U$1.47 (PC5/MTIOC3B/MTCLKD/SCK8), U$9.2
MTIOC4A: Q4.1 (G), R33.2, U$1.76 (PE2/MTIOC4A/RXD12/AN0)
unnamed: JP4.3, JP5.1
unnamed: JP4.4, JP5.2
unnamed: JP2.2, R9.2
unnamed: JP3.2, R10.1
unnamed: D1.K (C), X8.3
unnamed: D2.K (C), X8.4
unnamed: D3.K (C), X7.3
unnamed: D4.K (C), X7.4
unnamed: C10.2, D1.A, R15.1, U$8.1
unnamed: C11.2, D2.A, R16.1, U$9.1
unnamed: C12.2, D3.A, R17.1, U$10.1
unnamed: C13.2, D4.A, R18.1, U$11.1
unnamed: R22.2, U$58.4 (BLUE)
unnamed: R23.2, U$58.2 (GREEN)
unnamed: R24.2, U$58.1 (RED)
unnamed: Q1.3 (D), R22.1
unnamed: Q2.3 (D), R23.1
unnamed: Q3.3 (D), R24.1
unnamed: LED9.C, R34.2
unnamed: IC6.22 (RB1), JP7.5
unnamed: U$12.15 (UART_RTS), U$12.16 (UART_CTS)
unnamed: Q4.3 (D), SG2.1
unnamed: LED1.C, R25.2
unnamed: LED2.C, R26.2
unnamed: LED3.C, R27.2
unnamed: LED4.C, R28.2
unnamed: LED5.C, R11.2
unnamed: JP9.1, R12.1
unnamed: C1.1, U$1.5 (VCL)
unnamed: R1.2, U$1.15 (P35/NMI)
unnamed: IC1.2 (!RES), R35.1
unnamed: FT231XS.12 (USBDM), R40.2
unnamed: FT231XS.11 (USBDP), R41.2
unnamed: C21.2, FT231XS.3 (VCCIO), FT231XS.13 (3V3OUT), FT231XS.14 (RESET#)
unnamed: C22.2, R41.1, X14.3
unnamed: C23.2, R40.1, X14.2
unnamed: D7.C, U$18.1, X14.1
unnamed: C24.1, C25.1, FT231XS.15 (VCC), U$18.2
unnamed: R42.1, SJ1.2
unnamed: R43.1, SJ2.2
unnamed: LED10.C, R49.2
unnamed: R45.1, U$22.2 (D-)
unnamed: R44.1, U$22.3 (D+)
unnamed: R46.1, U$22.1 (VCC)
unnamed: LED11.C, R50.2
unnamed: IC6.14 (RB14), LED12.A
unnamed: C32.1, IC6.7 (VDDCORE)
unnamed: IC6.4 (RC8), IC6.5 (RC9)
unnamed: IC6.8 (RB10), X3.3
unnamed: IC6.9 (RB11), X3.2
unnamed: U$76.1, X3.1
unnamed: IC6.15 (RB15), LED13.A
unnamed: LED12.C, R52.2
unnamed: LED13.C, R53.2
unnamed: IC6.18 (!MCLR), JP7.1, R54.1
unnamed: IC6.21 (RB0), JP7.4
unnamed: LED14.C, R7.2
unnamed: R6.1, U$82.3, U$82.6
P07: JP6.2, R51.1, U$1.98 (P07)
P14: JP8.3, U$1.32 (P14/MTIOC3A/MTCLKA/CTX1)
P16: JP8.4, U$1.30 (P16/MTIOC3C/MTIOC3D/TXD1/RXD3)
P22: S4.3, S4.4 (P1), U$1.26 (P22/MTIOC3B/MTCLKC/SCK0), U$21.7
P23: S3.3, S3.4 (P1), U$1.25 (P23/MTIOC3D/MTCLKD/TXD3), U$21.5
P24: S2.3, S2.4 (P1), U$1.24 (P24/MTIOC4A/MTCLKA/SCK3), U$21.3
P25: S1.3, S1.4 (P1), U$1.23 (P25/MTIOC4C/MTCLKB/RXD3), U$21.1
P51: U$1.43 (P51/SCK2)
PA0: U$1.70 (PA0/MTIOC4A), X9.3
PA1: U$1.69 (PA1/MTIOC0B/MTCLKC/SCK5), X9.4
PA2: U$1.68 (PA2/RXD5), X9.5
PA3: U$1.67 (PA3/MTIOC0D/MTCLKD/RXD5), X9.6
PA4: U$1.66 (PA4/MTCLKA/TXD5), X9.7
PA5: U$1.65 (PA5), X9.8
PA6: U$1.64 (PA6/MTCLKB), X9.9
PA7: U$1.63 (PA7), X9.10
PB2: U$1.58 (PB2), U$12.5 (RESET)
PB3: Q3.1 (G), U$1.57 (PB3/MTIOC0A/MTIOC4A/SCK6), U$17.2
PB4: U$1.56 (PB4), U$17.4, U$58.3 (SW)
PB5: C15.1, R20.2, U$1.55 (PB5/MTIOC2A/MTIOC1B/SCK9), U$58.8 (A)
PB6: U$1.54 (PB6/MTIOC3D/RXD9)
PB7: C14.1, R19.2, U$1.53 (PB7/MTIOC3B/TXD9), U$58.6 (B)
PC0: Q2.1 (G), U$1.52 (PC0/MTIOC3C), U$17.6
PC1: Q1.1 (G), U$1.51 (PC1/MTIOC3A/TCLKA/RXD5), U$17.8
PC6: U$1.46 (PC6/MTIOC3C/MTCLKA/RXD8)
PC7: JP9.2, R8.2, U$1.45 (PC7/MTIOC3A/MTCLKB/TXD8), X1.10
PD6: LED4.A, U$1.80 (PD6/AN6)
PD7: LED3.A, U$1.79 (PD7/AN7)
PE0: LED2.A, U$1.78 (PE0/SCK12/ANEX0)
PE1: LED1.A, U$1.77 (PE1/MTIOC4C/TXD12/ANEX1)
PE3: LED9.A, U$1.75 (PE3/MTIOC4B/AN1)
RES#: R35.2, U$1.10 (RES#), U$24.6 (COM2), X1.13
RESETSW: S5.1 (S), S5.2 (S1), U$24.7 (NC2)
RSPCKB: U$1.73 (PE5/MTIOC4C/MTIOC2B/AN3), X10.4
RXD0: JP4.1, U$1.27 (P21/MTIOC1B/RXD0)
RXD1: U$1.20 (P30/TDI/MTIOC4B/RXD1), U$23.3, U$25.6 (COM2), X1.11
RXD2: U$1.42 (P52/RXD2), X5.3
RXD3/FT231TXD: FT231XS.20 (TXD), JP8.6, U$25.7 (NC2)
RXD5: U$1.50 (PC2/MTIOC4B/TCLKA/RXD5), X6.3
RXD6: U$1.61 (PB0/RXD6), U$12.14 (UART_TX)
SBDBTMD: IC6.43 (RB7), U$24.2 (NO1)
SBDBTRESET: IC6.44 (RB8), U$24.4 (NO2)
SBDBTRX: IC6.3 (RC7), U$25.2 (NO1)
SBDBTSW0: IC6.41 (RB5), R5.2, U$25.1 (IN1), U$25.5 (IN2)
SBDBTSW1: IC6.1 (RB9), R2.2, U$24.1 (IN1), U$24.5 (IN2)
SBDBTTX: IC6.2 (RC6), U$25.4 (NO2)
SCL0: SJ1.1, U$1.34 (P12/RXD2), X4.3
SDA0: SJ2.1, U$1.33 (P13/MTIOC0B/TXD2), X4.4
SSLB0: U$1.74 (PE4/MTIOC4D/MTIOC1A/AN2), X10.3
TCK: U$1.21 (P27/TCK/MTIOC2B/SCK1), U$23.5, X1.1
TMS: U$1.19 (P31/TMS/MTIOC4D), U$23.1, X1.9
TRST#: R4.2, U$1.16 (P34/MTIOC0A/SCK6/SCK0/USB0_DPRPD), X1.3
TXD0: JP4.2, U$1.28 (P20/MTIOC1A/TXD0)
TXD1: U$1.22 (P26/TDO/MTIOC2A/TXD1), U$23.7, U$25.10 (COM1), X1.5
TXD2: U$1.44 (P50/TXD2), X5.4
TXD3/FT231RXD: FT231XS.4 (RXD), U$1.29 (P17/MTIOC3A/MTIOC3B/SCK1/TXD3), U$25.9 (NC1)
TXD5: U$1.49 (PC3/MTIOC4D/TCLKB/TXD5), X6.4
TXD6: U$1.59 (PB1/MTIOC0C/MTIOC4C/TXD6), U$12.13 (UART_RX)
USB0VBUS: C27.2, JP8.2, R46.2, R47.1
USB0_DM: R45.2, U$1.36 (USB0_DM)
USB0_DP: R44.2, R48.2, U$1.37 (USB0_DP)
USBDPUPE: JP8.1, R48.1
XCIN: C4.2, U$1.8 (XCIN), U$3.1
XCOUT: C5.2, U$1.9 (XCOUT), U$3.2
XTAL: C2.1, U$1.11 (P37/XTAL), XTAL1.1

Notes on the sheet:
PIC24FJ64GB004のつもり
USB_HOST
USB
